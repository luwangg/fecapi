<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ber_generator</value></param>
<param><key>title</key><value>BER Generator</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>FEC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framebits</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import fec</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_encoder_def</key>
<param><key>id</key><value>cc_encoder</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_decoder_def</key>
<param><key>id</key><value>cc_decoder</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threading</value></param>
<param><key>value</key><value>capillary</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>generic_encoder</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>generic_decoder</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>value</key><value>'1101'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>100000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_decoder_interface</key>
<param><key>id</key><value>variable_decoder_interface_0</value></param>
<param><key>value</key><value>statdard_decoder_interface</value></param>
<param><key>decoder_list</key><value>cc_decoder[0]</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>ann</key><value>None</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
</block>
<block>
<key>encoder_interface</key>
<param><key>id</key><value>encoder_interface_0</value></param>
<param><key>encoder_list</key><value>cc_encoder[0]</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>berminerrors</value></param>
<param><key>value</key><value>200</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>berlimit</value></param>
<param><key>value</key><value>-7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>esno</value></param>
<param><key>label</key><value>EsNo</value></param>
<param><key>value</key><value>[2,]</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fec_ber_bf</key>
<param><key>id</key><value>fec_ber_bf_0_0</value></param>
<param><key>berminerrors</key><value>berminerrors</value></param>
<param><key>berlimit</key><value>berlimit</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>50</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>esno_gui</value></param>
<param><key>label</key><value>Es/N0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
</block>
<block>
<key>fec_gaussnoise_ff</key>
<param><key>id</key><value>fec_gaussnoise_ff_0</value></param>
<param><key>esno</key><value>esno_gui</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-7</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>fec_ber_bf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>fec_ber_bf_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>encoder_interface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>variable_decoder_interface_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>encoder_interface_0</source_block_id><sink_block_id>fec_gaussnoise_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_gaussnoise_ff_0</source_block_id><sink_block_id>variable_decoder_interface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
